Commit message: move

File: public/kr1/urdf/kr1修改姿态暂时存储.urdf (robot description, URDF)
Before this commit: robot kr1, 7 links, 6 joints
Joints:
- joint joint2: axis 0 -1 0 -> 0 1 0
- joint joint3: axis 0 -1 0 -> 0 1 0
- joint joint4: axis 0 -1 0 -> 0 1 0
